# IAR project BasicProject.ewp, settings and files
configuration Debug ($TARGET$, debug)
  group (top)
    ../BasicProject/: main.c
