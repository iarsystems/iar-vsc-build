# IAR project test_project.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: RX600 Generic RX600
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCDefines: MY_SYMBOL=42; MY_SYMBOL2="test"
  ICCRX.PreInclude: preincluded.h
  ICCRX.CCIncludePath2: inc
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group (top)
    ./: util.c main.c cpp.cpp
