<?xml version="1.0" encoding="UTF-8"?>
<!-- some comment-->
<workspace>
    <project>
        <path>$WS_DIR$/test_project.ewp</path>
    </project>
    <project>
        <path>/home/nonexistent.ewp</path>
    </project>
    <batchBuild />
</workspace>