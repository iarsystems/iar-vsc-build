# IAR project SourceConfigurationNoDefines.ewp, settings and files
configuration TheConfiguration (RH850, debug)
  General.GDeviceSelect: UnspecifiedG3M RH850 G3M - Unspecified
  General.GHeapSize: 0x1000
  ICCRH850.IccLang: 0
  ICCRH850.CCOptLevel: 1
  ICCRH850.CCOptStrategy: 0
  ICCRH850.CCIncludePath2: $WS_DIR$/SourceConfiguration/Project; ../Library/inc
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  group (top)
    ./: main.c readme.txt
  group lib
    ../Library/src/: gpio.c
