# IAR project SourceConfigurationNoDefines.ewp, settings and files
configuration TheConfiguration (RISCV, debug)
  General.GDeviceSelect: RV32 RV32
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCIncludePath2: inc; $WS_DIR$/SourceConfiguration/Project; ../Library/inc
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: template_riscv.out
  group (top)
    ./: main.c readme.txt
  group lib
    ../Library/src/: gpio.c
