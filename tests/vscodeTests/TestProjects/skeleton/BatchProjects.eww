<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/BasicProject/BasicProject.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TestBatch</name>
            <member>
                <project>BasicProject</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>BasicProject</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>