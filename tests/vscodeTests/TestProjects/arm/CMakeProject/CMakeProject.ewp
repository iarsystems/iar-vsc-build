# IAR project CMakeProject.ewp, settings and files
configuration IWillBeRemoved (CMake_ARM, debug)
  group (top)
    ./: CMakeLists.txt
