# IAR project SourceConfiguration.ewp, settings and files
configuration TheConfiguration (ARM, debug)
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER=1; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: $WS_DIR$/SourceConfiguration/Project; ../Library/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ./: main.c readme.txt
  group lib
    ../Library/src/: gpio.c
