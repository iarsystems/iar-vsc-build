# IAR project BasicProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: main.c
