# IAR project SourceConfiguration.ewp, settings and files
configuration TheConfiguration (RX, debug)
  General.OGChipSelectMenu: RX600 Generic RX600
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCDefines: USE_STDPERIPH_DRIVER=1; HSE_VALUE=8000000
  ICCRX.CCIncludePath2: $WS_DIR$/SourceConfiguration/Project; ../Library/inc
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  group (top)
    ./: main.c readme.txt
  group lib
    ../Library/src/: gpio.c
