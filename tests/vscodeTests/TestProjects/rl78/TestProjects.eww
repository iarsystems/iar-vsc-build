<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/ArgVars/ArgVars.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$/GettingStarted/BasicDebugging.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$/C-STATProject/C-STATProject.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$/SourceConfiguration/Project/SourceConfiguration.ewp</path>
    </project>
    <batchBuild />
</workspace>
