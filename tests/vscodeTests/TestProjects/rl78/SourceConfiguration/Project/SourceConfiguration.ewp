# IAR project SourceConfiguration.ewp, settings and files
configuration TheConfiguration (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: USE_STDPERIPH_DRIVER=1; HSE_VALUE=8000000
  ICCRL78.CCIncludePath2: $WS_DIR$/SourceConfiguration/Project; ../Library/inc
  OBJCOPY.OOCOutputFile: templproj.srec
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  group (top)
    ./: main.c readme.txt
  group lib
    ../Library/src/: gpio.c
