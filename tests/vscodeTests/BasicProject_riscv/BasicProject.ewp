# IAR project BasicProject.ewp, settings and files
configuration Debug ($TARGET$, debug)
  General.GDeviceSelect: RV32 RV32
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
